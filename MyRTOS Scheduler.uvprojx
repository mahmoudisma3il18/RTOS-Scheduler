# Keil uVision project MyRTOS Scheduler.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyRTOS Scheduler
  group Src
    ./Src/: main.c
  group RTOS Layers
    ./RTOS Layers/: CortexMx_OS_Porting.c scheduler.c FIFO.c
  group Startup
    ./Startup/: startup_stm32f103c8tx.s
