# Keil uVision project MyRTOS.uvprojx, settings and files
target Target 1 (ARM-GNU)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MyRTOS
  group Source Group 1
    ./Startup/: startup_stm32f103c8tx.s
    ./Src/: main.c
  group HAL
    ./HAL/: keypad.c lcd.c
  group MCAL
    ./Stm32_F103C6_Drivers/: stm32f103x8_RCC_driver.c stm32f103x8_SPI_Drver.c stm32f103x8_EXTI_driver.c stm32f103x8_USART_driver.c
    ./Stm32_F103C6_Drivers/GPIO/: stm32f103x8_gpio_driver.c
  group My_RTOS
    ./My_RTOS/: CortexMx_OS_Porting.c FIFO.c scheduler.c
